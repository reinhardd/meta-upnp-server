
PACKAGECONFIG:append = " \
dashboard \
storaged \
"
