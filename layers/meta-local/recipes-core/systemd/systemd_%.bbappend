 

PACKAGECONFIG:remove = " networkd quotacheck ima sysvinit "
PACKAGECONFIG:append = " coredump "
